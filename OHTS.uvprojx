# Keil uVision project OHTS.uvprojx, settings and files
target OHTS (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM4 ARM
  pack: ARM.CMSIS.5.4.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M4") CLOCK(12000000) ESEL ELITTLE
  output: OHTS
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\include
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group user
    ./user/: main.c
  group RTOS/Source
    ./include/: list.h portmacro.h FreeRTOSConfig.h
    ./rtos/: list.c
  group doc
    ./doc/: readme.txt
software components: CMSIS:CORE 5.1.2, Device:Startup 1.0.1
